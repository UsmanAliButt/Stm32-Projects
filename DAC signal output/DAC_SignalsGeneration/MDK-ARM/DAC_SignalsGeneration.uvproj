# Keil uVision project DAC_SignalsGeneration.uvproj, settings and files
target DAC_SignalsGeneration (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F051R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: DAC_SignalsGeneration
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: ..\;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\CMSIS\ST\STM32F0xx\Include;..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\..\..\..\Utilities\STM32F0-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ../: main.c stm32f0xx_it.c system_stm32f0xx.c stm32f0xx_lp_modes.c
  group STM32F0-Discovery
    ../../../../Utilities/STM32F0-Discovery/: stm32f0_discovery.c
  group STM32F0xx_StdPeriph_Driver
    ../../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_rcc.c stm32f0xx_gpio.c stm32f0xx_syscfg.c stm32f0xx_exti.c stm32f0xx_misc.c stm32f0xx_tim.c stm32f0xx_dma.c stm32f0xx_dac.c stm32f0xx_pwr.c stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dbgmcu.c stm32f0xx_flash.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_rtc.c stm32f0xx_wwdg.c
  group MDK-ARM
    ../../../../Libraries/CMSIS/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
